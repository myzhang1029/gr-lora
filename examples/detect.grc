options:
  parameters:
    author: myzhang1029
    generate_options: qt_gui
    id: detect
    output_language: python
    title: Detect from File
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 500e3/4
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 920e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 2**sf/bw > 16e-3
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/zmy/Git/srip/LoRa packets on SDR/sample_sdr_data_g50dB.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_detect_0
  id: lora_detect
  parameters:
    beta: '25.0'
    fft_factor: '10'
    filename_template: '%Y-%m-%d_%H%M%S_XXXX.dat'
    fs_bw_ratio: '2'
    on_length: '30000'
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: '8'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bw/2+10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_RECTANGULAR
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2*bw/samp_rate
    type: ccf
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', lora_detect_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
